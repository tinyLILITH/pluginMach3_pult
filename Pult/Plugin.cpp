//=====================================================================
//actual version
//	Plugin.cpp - the optional custom part of the plugin
//
//	this source file can be filled with the actual custom code that
//	makes the plugin work. it is the choice of the developer to enable
//	which functions will be used from the available MachDevice calls.
//
//	if this is a mixed mode dll each function can be declared as either
//	an unmanaged or managed function.
//
//	please see the documentation in Plugin.h for the #define stateInputments
//	that control each functions compilation.
//
//	if this is a mixed mode dll and you need to keep global managed
//	reference please see the MG class in ManagedGlobal.h
//
//	please read the notes and comments in MachDevice.cpp for general
//	information and disclaimers.
//
//=====================================================================
/*




*/
#include "stdafx.h"
#include "Plugin.h"
#include "MachDevice.h"
#include "ConfigDialog.h"
#include "PlugInControlDialog.h"
#include "XMLNetProfile.h"
#include "ManagedGlobal.h"
#include <stdlib.h>
#include <windows.h>
#include <string>

//---------------------------------------------------------------------
//	the default namespace for managed functions and classes
//---------------------------------------------------------------------

using namespace tst;




//---------------------------------------------------------------------
//	data area
//---------------------------------------------------------------------
int menuStart = 0;
bool lptCommandSent = false, erlsCommandSent = false, drvCommandSent = false;

String^ readSetting(String^ node){

	XMLNetProfile ^ profile = gcnew XMLNetProfile(gcnew String(ProfileName), "Pult-Control", true);

	if (profile -> Load()) {
		return profile -> ReadString(node);
	}
return "Nothing to return";
}

String^ writeSetting(String^ node, String^ parametr){

	XMLNetProfile ^ profile = gcnew XMLNetProfile(gcnew String(ProfileName), "Pult-Control", true);

	if (profile -> Load()) {
		profile->WriteString(node,parametr);
		
	}
return "Nothing to return";
}


String^ waitForResponse(int timeoutMs) {
    DateTime start = DateTime::Now;

    while ((DateTime::Now - start).TotalMilliseconds < timeoutMs) {
        if (MG::CD->Serial->BytesToRead > 0) {
            String^ resp = MG::CD->Serial->ReadExisting();

            return resp;
        }

        System::Threading::Thread::Sleep(10);
    }

    return "";
}

// Функция для отправки команды CMD_PURDY и получения ответа
bool sendPurtyCommand() {
    String^ commandStr = CMD_PURDY;
    array<unsigned char>^ command = System::Text::Encoding::ASCII->GetBytes(commandStr);
    MG::CD->Serial->Write(command, 0, command->Length);
    MG::PCD->listBox1->Items->Add("Попытка отправить команду: " + commandStr);

    // Ожидание ответа
    Threading::Thread::Sleep(100);

    int bytesToRead = MG::CD->Serial->BytesToRead;
    
    if (bytesToRead > 0) {
        String^ response = waitForResponse(100); // ответ на запуск платы
        MG::PCD->listBox1->Items->Add("Ответ устройства: " + response);

        if (response->Contains(RESP_PUOK)) {
            return true; // Успешное подтверждение
        } else {
            MG::PCD->listBox1->Items->Add("Некорректный ответ: " + response);
            return false; // Некорректный ответ
        }
    } else {
        MG::PCD->listBox1->Items->Add("Нет ответа от устройства. Повторная попытка...");
        return false; // Нет ответа
    }
}

bool sendDRVCommand(bool currentState) {
    String^ drvCmd = (currentState == true) ? CMD_DRV_ON : CMD_DRV_OFF;
    MG::CD->Serial->Write(drvCmd);
    MG::PCD->listBox1->Items->Add("Отправлено: " + drvCmd->Trim());

    // Ожидание ответа на команду
    String^ drvResponse = waitForResponse(100); // ответ на запуск драйверов

    if ((currentState == true && drvResponse->Contains(RESP_DRV_ON)) || 
        (currentState == false && drvResponse->Contains(RESP_DRV_OFF))) {
        MG::PCD->listBox1->Items->Add("Подтверждение DRV получено: " + drvResponse);
        return true; // Успех
    } else {
        MG::PCD->listBox1->Items->Add("Нет подтверждения DRV: " + drvResponse);
        return false; // Неудача
    }
}

bool sendLPTCommand(bool currentState) {
    String^ lptCmd = (currentState == true) ? CMD_LPT_ON : CMD_LPT_OFF;
    MG::CD->Serial->Write(lptCmd);
    MG::PCD->listBox1->Items->Add("Отправлено: " + lptCmd->Trim());

    // Ожидание ответа на команду
    String^ lptResponse = waitForResponse(100); // ответ на запуск драйверов

    if ((currentState == true && lptResponse->Contains(RESP_LPT_ON)) || 
        (currentState == false && lptResponse->Contains(RESP_LPT_OFF))) {
        MG::PCD->listBox1->Items->Add("Подтверждение LPT получено: " + lptResponse);
        return true; // Успех
    } else {
        MG::PCD->listBox1->Items->Add("Нет подтверждения LPT: " + lptResponse);
        return false; // Неудача
    }
}

// Основная функция init
void init() {

    try {
        MG::_mInst->SetUserLED(LED_PURDY, 0); // Выключаем индикатор готовности
        MG::_mInst->SetUserLED(LED_DRVCHECK, 0);
        MG::_mInst->SetUserLED(LED_LPTCHECK, 0);
        
        MG::_mInst->SetVar(DRV_VAR, 1);
        MG::_mInst->SetVar(LPT_VAR, 1);
        MG::currentStateDRV = static_cast<int>(MG::_mInst->GetVar(DRV_VAR));
        MG::currentStateLPT = static_cast<int>(MG::_mInst->GetVar(LPT_VAR));

        // Чтение настроек порта
        String^ portSetting = readSetting("PORT");

        if (String::IsNullOrEmpty(portSetting)) {
            MG::PCD->listBox1->Items->Add("Порт не назначен. Назначьте порт в Config Plugin и перезапустите Mach3.");
            return;
        }

        MG::PCD->listBox1->Items->Add("Настройка порта: " + portSetting);

        // Закрытие порта, если он открыт
        if (MG::CD->Serial->IsOpen) {
            MG::PCD->listBox1->Items->Add("Закрытие открытого порта...");
            MG::CD->Serial->Close();
        }

        // Настройка порта
        MG::CD->Serial->PortName = portSetting;
        // Открытие порта
        MG::CD->Serial->Open();
        MG::PCD->listBox1->Items->Add("Порт успешно открыт");

        // Ожидание для завершения инициализации устройства
        Threading::Thread::Sleep(100); // Увеличьте при необходимости

        // Очистка буферов после открытия порта
        MG::CD->Serial->DiscardInBuffer();
        MG::CD->Serial->DiscardOutBuffer();
        MG::PCD->listBox1->Items->Add("Буферы очищены");

        // Цикл отправки команды ?PURDY$
        bool commandSent = false;
        for (int attempt = 0; attempt < 5; attempt++) {
            Threading::Thread::Sleep(50); // Задержка перед отправкой команды

            if (sendPurtyCommand()) {  // Отправка команды CMD_PURDY и проверка ответа
                MG::_mInst->SetUserLED(LED_PURDY, 1); // Включаем индикатор готовности
                
                bool DRVCommandSuccess = sendDRVCommand(MG::currentStateDRV); // Отправка команды на драйвер
				bool LPTCommandSuccess = sendLPTCommand(MG::currentStateLPT); // Отправка команды на LPT
				
                if (DRVCommandSuccess) {
                    commandSent = true;
                    MG::_mInst->SetUserLED(LED_DRVCHECK, MG::currentStateDRV);
                } 
                else {
                    MG::_mInst->SetUserLED(LED_DRVCHECK, MG::currentStateDRV);
                }
              
                if (LPTCommandSuccess) {
                    MG::initComplete = true;
                    commandSent = true;
                    MG::_mInst->SetUserLED(LED_LPTCHECK, MG::currentStateLPT);
                    break; 
                } 
                else {
                    MG::_mInst->SetUserLED(LED_LPTCHECK, MG::currentStateLPT);
                }
              
                
            }
        }

        if (!commandSent) {
            throw gcnew System::Exception("Устройство не отвечает. Попробуйте повторное подключение.");
        }
    } catch (System::Exception^ e) {
        MG::PCD->listBox1->Items->Add("Ошибка init: " + e->Message);
        MG::_mInst->SetUserLED(LED_PURDY, 0); // Выключаем индикатор готовности
    }
}		 

	 




static double savedSpeed = -1;
static bool fastJogActive = false;

void mainThread() {

    String^ response = waitForResponse(50);
    bool commandFound = false;

     // --- Команда ESTOP  ---
    if (response->Contains(RESP_ESTOP)) {
        MG::PCD->listBox1->Items->Add("Остановка STOP: " + response);
       //MG::_mInst->DoButton(3);	//STOP
        if (!MG::_mInst->IsEstop()) {MG::_mInst->DoButton(21);} 
       commandFound = true;
    }

   if (response->Contains(RESP_ERLS)) {
        MG::PCD->listBox1->Items->Add("Остановка STOP: " + response);
       //MG::_mInst->DoButton(3);	//STOP
        if (MG::_mInst->IsEstop()) {MG::_mInst->DoButton(21);}          	
       commandFound = true;																			 
    }
   //---------------------------------------
    
    //CYCLE START
    
    if (response->Contains(RESP_CYCLE_START)) {
       MG::PCD->listBox1->Items->Add("Запуск цикла обработки " + response);
       MG::_mInst->DoOEMButton(1000);	//STOP
        
       MG::_mInst->SetVar(CNT_VAR, MG::_mInst->GetVar(CNT_VAR)+1 ); // инкрементация счётчика при запуске цикла с кнопки
       MG::_mInst->SetOEMDRO(CYCLE_COUNTER,MG::_mInst->GetVar(CNT_VAR)); //Обновляем отображаемое значение
            	
       commandFound = true;																			 
    }
   //------------------------------------
   
    
    //SOFT STOP / PAUSE
    
    if (response->Contains(RESP_CYCLE_SOFT_STOP)) {
       MG::PCD->listBox1->Items->Add("Запуск цикла обработки " + response);
       MG::_mInst->DoOEMButton(1003);	// SOFT STOP       	
       commandFound = true;																			 
    }
   //------------------------------------
   
   
    //USER BUTTON CODE 1   
    
    if (response->Contains(UCB1) ) {
       MG::PCD->listBox1->Items->Add("Запуск цикла обработки " + response);
       MG::_mInst->DoOEMButton( System::Convert::ToInt32( readSetting("B1")) );	// USER BUTTON CODE 1    	
       commandFound = true;																			 
    }
   //------------------------------------ 
    
       //USER BUTTON CODE 2   
    
    if (response->Contains(UCB2) ) {
       MG::PCD->listBox1->Items->Add("Запуск цикла обработки " + response);
       MG::_mInst->DoOEMButton( System::Convert::ToInt32(readSetting("B2")) );	// USER BUTTON CODE 2    	
       commandFound = true;																			 
    }
   //------------------------------------
   
       //USER BUTTON CODE 3   
    
    if (response->Contains(UCB3) ) {
       MG::PCD->listBox1->Items->Add("Запуск цикла обработки " + response);
       MG::_mInst->DoOEMButton( System::Convert::ToInt32(readSetting("B3")) );	// USER BUTTON CODE 3    	
       commandFound = true;																			 
    }
   //------------------------------------  
       //USER BUTTON CODE 4   
    
    if (response->Contains(UCB4) ) {
       MG::PCD->listBox1->Items->Add("Запуск цикла обработки " + response);
       MG::_mInst->DoOEMButton( System::Convert::ToInt32(readSetting("B4")) );	// USER BUTTON CODE 4    	
       commandFound = true;																			 
    }
   //------------------------------------
   
       //USER BUTTON CODE 5   
    
    if (response->Contains(UCB5) ) {
       MG::PCD->listBox1->Items->Add("Запуск цикла обработки " + response);
       MG::_mInst->DoOEMButton( System::Convert::ToInt32(readSetting("B5")) );	// USER BUTTON CODE 5    	
       commandFound = true;
																		 
    }
   //------------------------------------ 
   
   //ALARM X  
    
    if (response->Contains(ALMX) ) {
       MG::PCD->listBox1->Items->Add("Ошибка привода X " + response);
        MG::_mInst->SetUserLED(LED_ALM_X,1);
        
	 if(MG::XZSTOP)
       {
		MG::_mInst->DoOEMButton(MG::UserButtons[5]);
		MG::_mInst->Message("Driver X has stopped");
       }  	
       
         	
       commandFound = true;
																		 
    }
    
    if (response->Contains(ALMX_RLS) ) {
       MG::PCD->listBox1->Items->Add("X ошибка снята " + response);
       MG::_mInst->SetUserLED(LED_ALM_X,0);
               
       commandFound = true;
																		 
    }
    //----------------------------------
      
   //ALARM Z  
    
	   if (response->Contains(ALMZ) ) {
       MG::PCD->listBox1->Items->Add("Ошибка привода Z " + response);
       MG::_mInst->SetUserLED(LED_ALM_Z,1);
       
       if(MG::XZSTOP)
       {
		MG::_mInst->DoOEMButton(MG::UserButtons[5]);
		MG::_mInst->Message("Driver Z has stopped");
       }
           	
       commandFound = true;
																		 
    }
    
   if (response->Contains(ALMZ_RLS) ) {
       MG::PCD->listBox1->Items->Add("Z ошибка снята " + response);
        MG::_mInst->SetUserLED(LED_ALM_Z,0);  	
       commandFound = true;
																		 
    }
    //---------------------------------- 
    if (!commandFound) {
        MG::PCD->listBox1->Items->Add("Неизвестная команда: " + response);
    }
}

			


   
 // Основной поток обновления (опрос COM порта, проверка инициализации) попытки увеличить скорость отклика 
 //при инициализации(пока безрезультатно, упираемся в скорость инициализации МК)

void MG::mainThreadUpdateCOM()
{
    while (!stopThread) // проверка флага завершения
    {
        try
        {
            // Проверка инициализации и открытия порта
            if (!MG::initComplete || !MG::CD->Serial->IsOpen)
            {
                MG::PCD->listBox1->Items->Add("Попытка инициализации...");
                init();
                System::Threading::Thread::Sleep(100); // даём время на инициализацию  
            }

            

if (MG::currentStateDRV != MG::_mInst->GetVar(DRV_VAR))
{
    // Получаем новое состояние
    bool newState = MG::_mInst->GetVar(DRV_VAR) == 1;

    if (newState) // Если состояние изменилось на включение
    {   
        sendDRVCommand(true);  // Отправляем команду на включение драйвера
        MG::_mInst->SetUserLED(LED_DRVCHECK, 1);  // Включаем индикатор
    }
    else // Если состояние изменилось на выключение
    {
        sendDRVCommand(false);  // Отправляем команду на выключение драйвера
        MG::_mInst->SetUserLED(LED_DRVCHECK, 0);  // Выключаем индикатор
    }

    // Обновляем переменную состояния
    MG::currentStateDRV = newState;  // Обновляем текущий статус
    //MG::prevStateDRV = MG::_mInst->GetVar(DRV_VAR); // Обновляем предыдущее состояние
}


if (MG::currentStateLPT != MG::_mInst->GetVar(LPT_VAR))
{
    // Получаем новое состояние
    bool newState = MG::_mInst->GetVar(LPT_VAR) == 1;

    if (newState) // Если состояние изменилось на включение
    {   
        sendLPTCommand(true);  // Отправляем команду на включение драйвера
        MG::_mInst->SetUserLED(LED_LPTCHECK, 1);  // Включаем индикатор
    }
    else // Если состояние изменилось на выключение
    {
        sendLPTCommand(false);  // Отправляем команду на выключение драйвера
        MG::_mInst->SetUserLED(LED_LPTCHECK, 0);  // Выключаем индикатор
    }

    // Обновляем переменную состояния
    MG::currentStateLPT = newState;  // Обновляем текущий статус
    //MG::prevStateDRV = MG::_mInst->GetVar(DRV_VAR); // Обновляем предыдущее состояние
}


            // --- Опрос порта ---
            if (MG::CD->Serial->BytesToRead > 0)
            {
                mainThread(); // твоя основная логика
            }
            else
            {
                System::Threading::Thread::Sleep(10); // разгрузка CPU
            }
        }
        catch (System::Exception^ e)
        {
            MG::PCD->listBox1->Items->Add("Ошибка mainThreadUpdateCOM: " + e->Message);
            MG::_mInst->SetUserLED(LED_DRVCHECK, 0);
            MG::initComplete = false;

            System::Threading::Thread::Sleep(100); // пауза перед повтором
        }
    }

    // --- Поток завершён, освобождаем COM объекты ---
    if (_mInst != nullptr) Marshal::ReleaseComObject(_mInst);
    if (_mach != nullptr) Marshal::ReleaseComObject(_mach);
    _mInst = nullptr;
    _mach = nullptr;

    MG::PCD->listBox1->Items->Add("mainThreadUpdateCOM завершён");
}








							   


//---------------------------------------------------------------------
//
//	piInitControl() - Plugin extension of InitControl()
//
//		XML file can NOT be accessed since SetProName hasn't
//		been called yet
//
//		called EVEN if plugin is disabled
//
//---------------------------------------------------------------------

#ifdef PI_INITCONTROL
#ifdef _MANAGED
#pragma PI_MIX_INITCONTROL
#endif
bool piInitControl() {
  menuStart = GetMenuRange(MENU_COUNT);
  


  return true;
}
#endif

//---------------------------------------------------------------------
//
//	piSetProName() - Plugin extension of SetProName()
//
//		XML file CAN be accessed
//
//		called EVEN if plugin is disabled
//
//---------------------------------------------------------------------

#ifdef PI_SETPRONAME
#ifdef _MANAGED
#pragma PI_MIX_SETPRONAME
#endif
char * piSetProName(LPCSTR name) {
  XMLNetProfile ^ profile = gcnew XMLNetProfile(gcnew String(ProfileName), "Pult-Control", true);

  profile -> Load();

  MG::_mInst->SetUserLED(LED_PURDY,0); // Выключаем светодиод для индикации о том, что устройство не подключено
  
      //Start threat for updateCOM Port

	MG::threadUpdateCOM->Start();
	
	


  return "Pult Control";
}
#endif

//---------------------------------------------------------------------
//
//	piPostInitControl() - Plugin extension of PostInitControl()
//
//		XML file can NOT be accessed
//
//		called ONLY if plugin is enabled
//
//---------------------------------------------------------------------

#ifdef PI_POSTINITCONTROL
#ifdef _MANAGED
#pragma PI_MIX_POSTINITCONTROL
#endif
void piPostInitControl() {


  // Store a reference to the form in the ManagedGlobal class for later use

  HMENU hMachMenu = GetMenu(MachView -> MachFrame -> m_hWnd);
  HMENU hPluginMenu = 0;
  int machMenuCnt = GetMenuItemCount(hMachMenu);
  MENUITEMINFO mii;
  LPTSTR txt;

  for (int i = 0; i < machMenuCnt; i++) {
    mii.cbSize = sizeof(MENUITEMINFO);
    mii.fMask = MIIM_FTYPE | MIIM_ID | MIIM_SUBMENU | MIIM_STRING;
    mii.dwTypeData = NULL;

    if (GetMenuItemInfo(hMachMenu, i, true, & mii)) {
      txt = (LPTSTR) malloc(++mii.cch);
      mii.dwTypeData = txt;

      if (GetMenuItemInfo(hMachMenu, i, true, & mii)) {
        if (strcmp(txt, "PlugIn Control") == 0) {
          hPluginMenu = mii.hSubMenu;
          i = machMenuCnt;
        }
      }

      free(txt);
    }

    if (hPluginMenu) {
       InsertMenu(hPluginMenu, -1, MF_BYPOSITION, menuStart, "Pult Control"); // Вставить плагин в выпадающее меню mach3
    }
  }



//Показ окна
  MG::PCD -> Show();
  


      try
    {
    
    //Чтение настроек их конфигурационного файла mach3turn.xml
	
	MG::UserButtons[0] = Int32::Parse (readSetting("B1"));
	MG::UserButtons[1] = Int32::Parse (readSetting("B2"));
	MG::UserButtons[2] = Int32::Parse (readSetting("B3"));
	MG::UserButtons[3] = Int32::Parse (readSetting("B4"));
	MG::UserButtons[4] = Int32::Parse (readSetting("B5"));
	MG::UserButtons[5] = Int32::Parse (readSetting("AUTOSTOPCODE"));
	MG::XZSTOP = Boolean::Parse(readSetting("AUTOSTOP"));  
    }
    
    catch (Exception^ ex)
    {
		 MessageBox::Show("При чтении значений OEM кодов кнопок произошла ошибка", "Ошибка", MessageBoxButtons::OK, MessageBoxIcon::Error);
    }

}
#endif

//---------------------------------------------------------------------
//
//	piConfig() - Plugin extension of Config()
//
//		called if user presses CONFIG in Config|Config Plugins
//		even if plugin is disabled
//
//		XML file CAN be accessed
//
//---------------------------------------------------------------------

#ifdef PI_CONFIG
#ifdef _MANAGED
#pragma PI_MIX_CONFIG
#endif
void piConfig() {
	MG::CD -> ShowDialog();
	
}
#endif

//---------------------------------------------------------------------
//
//	piStopPlug() - Plugin extension of StopPlug()
//
//---------------------------------------------------------------------
#ifdef PI_STOPPLUG
#ifdef _MANAGED
#pragma PI_MIX_STOPPLUG
#endif
void piStopPlug() {
    try {
        if (MG::CD->Serial->IsOpen) {

            // Выключаем DRV
            MG::CD->Serial->WriteLine(CMD_DRV_OFF);
            MG::PCD->listBox1->Items->Add(String(CMD_DRV_OFF).Trim());
            String^ drvResponse = waitForResponse(100);

            // Выключаем LPT
            MG::CD->Serial->WriteLine(CMD_LPT_OFF);
            MG::PCD->listBox1->Items->Add(String(CMD_LPT_OFF).Trim());
            String^ lptResponse = waitForResponse(100);

            System::Threading::Thread::Sleep(100);

            // --- Корректное завершение потока ---
            MG::stopThread = true;

            if (MG::threadUpdateCOM->IsAlive)
            {
                MG::threadUpdateCOM->Join(); // ждём выхода потока
            }

            // Закрываем порт
            MG::CD->Serial->Close();

        } else {
            MG::_mInst->Message("Serial Port was not open");
        }

    } catch (System::Exception^ ex) {
        MG::PCD->listBox1->Items->Add("Ошибка при остановке плагина: " + ex->Message);
        MG::_mInst->SetUserLED(LED_PURDY, 0);
    }
}
#endif








//---------------------------------------------------------------------
//
//	piUpdate() - Plugin extension of Update()							»
//
//		XML file can NOT be accessed
//
//		called ONLY if plugin is enabled
//
//		WARNING - when you enable a plugin it immediately is added
//		to the update loop. if you haven't initialized some items
//		because PostInitControl() hasn't been called you can get
//		some problems!!!
//
//---------------------------------------------------------------------

#ifdef PI_UPDATE
#ifdef _MANAGED
#pragma PI_MIX_UPDATE
#endif
  
void piUpdate() {
//MainPlanner->JogActive=true;
}

#endif




//---------------------------------------------------------------------
//
//	piNotify() - Plugin extension of Notify()
//
//		among other notices this is where we are notified when the
//		user clicks on our 'PlugIn Control' menu item.
//
//		XML file CAN be accessed on a menu item notify
//
//---------------------------------------------------------------------

#ifdef PI_NOTIFY
#ifdef _MANAGED
#pragma PI_MIX_NOTIFY
#endif
void piNotify(int id) {
	
  if (id == menuStart) {
    //	xyzDemoConfig->enableDlg = MG::xyzDemoDialog->Visible;

    //вызов немодального окна
	  try{
		if (MG::PCD == nullptr || MG::PCD->IsDisposed)
			{
				MG::PCD = gcnew PlugInControlDialog();
			}

			MG::PCD->Show();
	  }
		
	  catch(System::Exception^ e) {
		  System::Windows::Forms::MessageBox::Show(e->Message);
	}
	
	     
	
  }
}
#endif

//---------------------------------------------------------------------
//
//	piDoDwell() - Plugin extension of DoDwell()
//
//---------------------------------------------------------------------

#ifdef PI_DODWELL
#ifdef _MANAGED
#pragma PI_MIX_DODWELL
#endif
void piDoDwell(double time) {

}
#endif

//---------------------------------------------------------------------
//
//	piReset() - Plugin extension of Reset()
//
//---------------------------------------------------------------------

#ifdef PI_RESET
#ifdef _MANAGED
#pragma PI_MIX_RESET
#endif

// Ф-я исполняется когда нажимаешь reset
void piReset() {

}

#endif

//---------------------------------------------------------------------
//
//	piJogOn() - Plugin extension of JogOn()
//
//---------------------------------------------------------------------

#ifdef PI_JOGON
#ifdef _MANAGED
#pragma PI_MIX_JOGON
#endif
void piJogOn(short axis, short dir, double speed) {

}

#endif

//---------------------------------------------------------------------
//
//	piJogOff() - Plugin extension of JogOff()
//
//---------------------------------------------------------------------

#ifdef PI_JOGOFF
#ifdef _MANAGED 
#pragma PI_MIX_JOGOFF
#endif
void piJogOff(short axis) {
	    MG::_mInst->JogOff(0);
        MG::_mInst->JogOff(1);
}
#endif

//---------------------------------------------------------------------
//
//	piPurge() - Plugin extension of Purge()
//
//---------------------------------------------------------------------

#ifdef PI_PURGE
#ifdef _MANAGED
#pragma PI_MIX_PURGE
void piPurge(short flags) {
   /*try {
    
    System::Threading::ThreadStart^ threadDelegate = gcnew System::Threading::ThreadStart(mainThreadUpdateCOM);
	System::Threading::Thread^ threadUpdateCOM = gcnew System::Threading::Thread(threadDelegate);
	
	
        if (MG::CD->Serial->IsOpen) {
            // Сначала отключаем DRV
            MG::CD->Serial->WriteLine(CMD_DRV_OFF);
            MG::PCD->listBox1->Items->Add(String(CMD_DRV_OFF).Trim());
			String^ drvResponse = waitForResponse (200);
			
			
            // Затем отключаем LPT
            MG::CD->Serial->WriteLine(CMD_LPT_OFF);
            MG::PCD->listBox1->Items->Add(String(CMD_LPT_OFF).Trim());
            String^ lptResponse = waitForResponse (200);
            
           MG::CD->Serial->Close();
       
	

        } else {
            MG::_mInst->Message("Serial Port was not open");
        }
    } catch (System::Exception^ e) {
        MG::PCD->listBox1->Items->Add("Ошибка STOPPLUG: " + e->Message);
        MG::_mInst->SetUserLED(LED_PURDY, 0);
    }*/
}
#endif
#endif

//---------------------------------------------------------------------
//
//	piProbe() - Plugin extension of Probe()
//
//---------------------------------------------------------------------

#ifdef PI_PROBE
#ifdef _MANAGED
#pragma PI_MIX_PROBE
#endif
void piProbe() {}
#endif

//---------------------------------------------------------------------
//
//	piHome() - Plugin extension of Home()
//
//---------------------------------------------------------------------

#ifdef PI_HOME
#ifdef _MANAGED
#pragma PI_MIX_HOME
#endif
void piHome(short axis) {}
#endif

